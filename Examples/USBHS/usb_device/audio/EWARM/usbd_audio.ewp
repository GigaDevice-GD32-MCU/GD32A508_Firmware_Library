# IAR project usbd_audio.ewp, settings and files
configuration GD32A508_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A508xE GD GD32A508xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A508; GD32A508_CL; USE_USB_FS; USE_USB_AD_MICPHONE; USE_USB_AD_SPEAKER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A508\Include; ..\..\..\..\..\Firmware\GD32A508_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\device\class\audio\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_audio.srec
  ILINK.IlinkOutputFile: CDC_ACM.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c audio_codec.c gd32a508_hw.c gd32a508_it.c
  group CMSIS
    ../src/: system_gd32a508.c
  group Doc
    ../: readme.txt
  group GD32A508_EVAL
    ../../../../../Utilities/: gd32a508z_eval.c
  group GD32A508_Peripherals
    ../../../../../Firmware/GD32A508_standard_peripheral/Source/: gd32a508_dma.c gd32a508_exmc.c gd32a508_exti.c gd32a508_gpio.c gd32a508_misc.c gd32a508_pmu.c gd32a508_rcu.c gd32a508_spi.c gd32a508_timer.c gd32a508_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A508/Source/IAR/: startup_gd32a508.s
  group USB_Class
    ../../../../../Firmware/GD32A508_usbhs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32A508_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32A508_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
