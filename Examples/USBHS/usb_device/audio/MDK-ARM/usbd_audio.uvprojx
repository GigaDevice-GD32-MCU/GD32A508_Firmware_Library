# Keil uVision project usbd_audio.uvprojx, settings and files
target GD32A508(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A508ZE GigaDevice
  pack: GigaDevice.GD32A508_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: usbd_audio +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32A508,GD32A508_CL,USE_STDPERIPH_DRIVER,USE_USB_FS,USE_USB_AD_SPEAKER USE_USB_AD_MICPHONE
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32A508\Include;..\..\..\..\..\Firmware\GD32A508_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\device\core\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\device\class\audio\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: app.c gd32A508_hw.c gd32A508_it.c audio_codec.c
  group CMSIS
    ../src/: system_gd32a508.c
  group GD32A508_Peripherals
    ../../../../../Firmware/GD32A508_standard_peripheral/Source/: gd32A508_exti.c gd32A508_gpio.c gd32A508_misc.c gd32A508_pmu.c gd32A508_rcu.c gd32A508_timer.c gd32A508_usart.c gd32A508_spi.c gd32A508_dma.c
  group GD32A508_EVAL
    ../../../../../Utilities/: gd32a508z_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A508/Source/ARM/: startup_gd32a508.s
  group USB_Driver
    ../../../../../Firmware/GD32A508_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32A508_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32A508_usbhs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
