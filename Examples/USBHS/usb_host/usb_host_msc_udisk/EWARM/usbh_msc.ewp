# IAR project usbh_msc.ewp, settings and files
configuration GD32A508_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A508xE GD GD32A508xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A508; USE_USB_FS; USE_FATFS
  ICCARM.CCIncludePath2: ..\inc; ..\fat_fs\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A508\Include; ..\..\..\..\..\Firmware\GD32A508_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\class\msc; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_msc.srec
  ILINK.IlinkOutputFile: USBH_MSC.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32A508_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A508; USE_USB_HS; USE_FATFS
  OBJCOPY.OOCOutputFile: USBD_Audio.srec
  group Application
    ../src/: gd32a508_it.c gd32a508_usb_hw.c lcd_font.c lcd_log.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32a508.c
  group Doc
    ../: readme.txt
  group FATFS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32A508_EVAL
    ../src/: gd32a508_lcd_eval.c
    ../../../../../Utilities/: gd32a508z_eval.c
  group GD32A508_Peripherals
    ../../../../../Firmware/GD32A508_standard_peripheral/Source/: gd32a508_exmc.c gd32a508_exti.c gd32a508_gpio.c gd32a508_misc.c gd32a508_pmu.c gd32a508_rcu.c gd32a508_timer.c gd32a508_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A508/Source/IAR/: startup_gd32a508.s
  group USB_Class
    ../../../../../Firmware/GD32A508_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32A508_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32A508_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
