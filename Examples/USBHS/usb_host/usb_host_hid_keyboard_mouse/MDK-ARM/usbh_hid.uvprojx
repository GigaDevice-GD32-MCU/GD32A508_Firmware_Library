# Keil uVision project usbh_hid.uvprojx, settings and files
target GD32A508(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A508ZE GigaDevice
  pack: GigaDevice.GD32A508_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: usbh_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32A508
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32A508\Include;..\..\..\..\..\Firmware\GD32A508_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\host\core\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\host\class\hid\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\common;..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\class\hid;..\..\..\..\..\Utilities;..\fat_fs\inc;..\..\..\..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: main.c usbh_usr.c gd32a508_it.c gd32a508_usb_hw.c usbh_usr_lcd.c lcd_font.c lcd_log.c
  group CMSIS
    ../src/: system_gd32a508.c
  group GD32A508_Peripherals
    ../../../../../Firmware/GD32A508_standard_peripheral/Source/: gd32a508_exti.c gd32a508_gpio.c gd32a508_misc.c gd32a508_pmu.c gd32a508_rcu.c gd32a508_timer.c gd32a508_usart.c gd32a508_exmc.c
  group GD32A508_EVAL
    ../../../../../Utilities/: gd32a508z_eval.c
    ../src/: gd32a508_lcd_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A508/Source/ARM/: startup_gd32a508.s
  group USB_Driver
    ../../../../../Firmware/GD32A508_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32A508_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32A508_usbhs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Doc
    ../: readme.txt
target GD32A508(USB_HS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A508ZE GigaDevice
  pack: GigaDevice.GD32A508_DFP.1.0.0
  cpu: as above
  output: usbh_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_HS
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32A508\Include;..\..\..\..\..\Firmware\GD32A508_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\host\core\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\host\class\hid\Include;..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\common;..\..\..\..\..\Firmware\GD32A508_usbhs_library\ustd\class\hid;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.3.0
