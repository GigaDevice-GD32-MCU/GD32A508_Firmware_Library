# Keil uVision project Project.uvprojx, settings and files
target GD32A508 (6120000::V6.12::.\ARMCLANG)
  device: GD32A508ZE GigaDevice
  pack: GigaDevice.GD32A508_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;..\..\Firmware\CMSIS;..\..\Firmware\GD32A508_standard_peripheral\Include;..\..\Utilities;..\..\Firmware\CMSIS\GD\GD32A508\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../: main.c systick.c gd32a508_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A508/Source/: system_gd32a508.c
  group Peripherals
    ../../Firmware/GD32A508_standard_peripheral/Source/: gd32a508_adc.c gd32a508_bkp.c gd32a508_can.c gd32a508_cmp.c gd32a508_crc.c gd32a508_ctc.c gd32a508_dac.c gd32a508_dbg.c gd32a508_dma.c gd32a508_enet.c gd32a508_exmc.c gd32a508_exti.c gd32a508_fmc.c gd32a508_fwdgt.c gd32a508_gpio.c gd32a508_i2c.c gd32a508_misc.c gd32a508_pmu.c gd32a508_rcu.c gd32a508_rtc.c gd32a508_shrtimer.c gd32a508_spi.c gd32a508_sqpi.c gd32a508_timer.c gd32a508_tmu.c gd32a508_usart.c gd32a508_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A508/Source/ARM/: startup_gd32a508.s
  group Utilities
    ../../Utilities/: gd32a508z_eval.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
