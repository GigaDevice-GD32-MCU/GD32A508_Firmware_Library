# IAR project Project.ewp, settings and files
configuration GD32A508 (ARM, debug)
  General.OGChipSelectEditMenu: GD32A508xE GD GD32A508xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\Firmware\GD32A508_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32A508\Include; ..\..\Firmware\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32a508_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A508/Source/: system_gd32a508.c
  group Doc
    ../: readme.txt
  group GD32A508_EVAL
    ../../Utilities/: gd32a508z_eval.c
  group GD32A508_Peripherals
    ../../Firmware/GD32A508_standard_peripheral/Source/: gd32a508_adc.c gd32a508_bkp.c gd32a508_can.c gd32a508_cmp.c gd32a508_crc.c gd32a508_ctc.c gd32a508_dac.c gd32a508_dbg.c gd32a508_dma.c gd32a508_enet.c gd32a508_exmc.c gd32a508_exti.c gd32a508_fmc.c gd32a508_fwdgt.c gd32a508_gpio.c gd32a508_i2c.c gd32a508_misc.c gd32a508_pmu.c gd32a508_rcu.c gd32a508_rtc.c gd32a508_shrtimer.c gd32a508_spi.c gd32a508_sqpi.c gd32a508_timer.c gd32a508_tmu.c gd32a508_usart.c gd32a508_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A508/Source/IAR/: startup_gd32a508.s
